# Keil uVision project f0ledblink.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: f0ledblink +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\source;..\lib\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\lib\Libraries\CMSIS\Device\ST\STM32F0xx;..\lib\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\lib\Libraries\STM32F0xx_StdPeriph_Driver\src;..\lib\Libraries\CMSIS\Include;..\lib\nrf24l01;..\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group startup
    ./source/: main.c startup_stm32f0xx.s system.c timer.c commands.c delay_asm.s com_modbus.c
    ../lib/: usart.c param_flash.c ext_int.c delay.c modbus.c
